# IAR project Rx_Firmwr.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC1110F32 CC1110F32
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  postbuild: C:\Users\encoad\Desktop\RX_Standard_2024\script\post_build.bat
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC1110F32.xcl
configuration Release (8051)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
  group (top)
    ./: flash_asm.s51 main.c
  group wdt
    MCAL/wdt/: wdt_config.h wdt_interface.h wdt_private.h wdt_program.c
